options:
  parameters:
    author: Scott Hollas
    generate_options: qt_gui
    id: car_freq_record
    output_language: python
    run_options: run
    title: read_car_open
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 434.4e6
  states: {}
- name: high_cutoff
  id: variable_qtgui_range
  parameters:
    label: High Cutoff
    orient: Qt.Horizontal
    start: 100e3
    step: '100'
    stop: 500e3
    value: '228300'
  states: {}
- name: low_cutoff
  id: variable_qtgui_range
  parameters:
    label: Low Cutoff
    orient: Qt.Horizontal
    start: '100'
    step: '100'
    stop: 10e3
    value: '300'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: TransitionWidth
    orient: Qt.Horizontal
    start: 1e3
    step: '100'
    stop: 500e3
    value: 1e3
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Filter out the jamming signals
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_cutoff
    low_cutoff_freq: low_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: Filter out the jamming signals
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_cutoff
    low_cutoff_freq: low_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2000000'
    type: complex
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_peak_detector_xb_1
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '0.01'
    threshold_factor_rise: '0.01'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom gnuradio import blocks\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Record Signal when peak detected',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n    def work(self, input_items, output_items):\n        try:\n            with open('tmp_recording', 'r') as f:\n                f=f.read()\n                with open('tmp_signal', 'r+') as f2:\n                    f_read=f2.read()\n                    if '0' in f_read:\n                     #   file = 'signal_1'\n                        f = np.fromfile(open(\"signal_1\"), dtype=np.complex64)\n                        f=np.append(f,input_items[0]) #Append to array \n                        f.astype(np.complex64).tofile(\"signal_1\") #Save the new array\n                    if '1' in f_read: #Start recording the second signal\n                        f = np.fromfile(open(\"signal_2\"), dtype=np.complex64)\n                        f=np.append(f,input_items[0]) #Append to array \n                        f.astype(np.complex64).tofile(\"signal_2\") #Save the new array\n\n                        #output_items[0][:] = 12345.123\n                        f2.seek(0)\n                        f2.write('3')\n                        #Record to signal 1\n                #if '1' in f:\n                 #   output_items[0][:] = input_items[0]\n\n        except Exception as e:\n            print(e)\n        return len(output_items[0])\n\n"
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import os
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Manage the peaking signal',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              try:
                  input_string = np.array2string(input_items[0]) #convert array to string
                  if '1' in input_string:
                      with open('tmp_start', 'r+') as s:
                          if s.read() == '0':
                              s.seek(0)  
                              s.write('1')
                      #Start recording if not already
                      with open('tmp_recording', 'w') as f:
                          f.write('1')
                  else: #The signal isn't peaking
                      #First check if the recording started
                      with open('tmp_start', 'r+') as s2:
                          if '0' in s2.read():
                              return len(output_items[0])
                      #Check if a counter has started already
                      with open('tmp_counter', 'r+') as f2:
                          counter=f2.read() #Read the file
                          if int(counter) == 1000: #Check if the counter has reached 50
                              counter=0
                              f2.seek(0)
                              f2.write('0') #Reset the counter
                              with open('tmp_recording', 'w') as w1: #Stop the recording file
                                  w1.write('0') #Stop recording
                                  with open('tmp_signal', 'r+') as s1: #Open signal file
                                      if s1.read() == '0': #This is the first signal
                                          s1.seek(0)  
                                          s1.write('1') #Start second recording
                                          print('First Recording Complete')
                                          #Reset start back to 0
                                          with open('tmp_start', 'w') as s3: #Resets the start back to 0, so the recording will start when the next peak is detected
                                              s3.seek(0)
                                              s3.write('0')
                                      else: #Both signals have been captured
                                          print('Both Recordings Complete') #stop listening and jamming and replay first signal, make led green?
                                          s1.seek(0)
                                          s1.write('2') #Stop the writing to file
                                          #Stop jamming
                                          try:
                                              os.system('nmcli con down id "ESPap 1"')
                                          except:
                                              print("ESPap was not connected")
                                          #Run the splitting file
                                          #import subprocess
                                          #exec(open("/home/scott/Documents/GNURadio/CAR/split_files.py").read())
                                          #exec(open("/home/scott/Documents/GNURadio/CAR/transmit_signal.py").read())
                                          #subprocess.call('/home/scott/Documents/GNURadio/CAR/split_files.py',shell=True)
                                          #subprocess.call('/home/scott/Documents/GNURadio/CAR/transmit_signal.py', shell=True)

                                          '''
                                          #Turn off amber led
                                          LED_PIN = 17
                                          GPIO.setmode(GPIO.BCM)
                                          GPIO.output(LED_PIN, GPIO.LOW)
                                          #Light Up Green Led
                                          LED_PIN = 17
                                          GPIO.setup(LED_PIN, GPIO.OUT)
                                          GPIO.output(LED_PIN, GPIO.HIGH)
                                          time.sleep(1)
                                          GPIO.output(LED_PIN, GPIO.LOW)
                                          GPIO.cleanup()
                                          '''

                          if int(counter) != 0: #The counter has started already
                              counter= int(counter)+1 #add one ot the counter
                              f2.seek(0)
                              f2.write(str(counter)) #Write the incremented value ot the file
                          else: #If the counter hasn't started
                              with open('tmp_counter', 'w') as f3: #Open the file for write
                                  f3.write('1') #Begin the count

              except Exception as e: 
                  print(e)
              #output_items[0][:] = output
              
              return len(output_items[0])
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: 100e3
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e3
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e3
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import os

      with open('tmp_recording', 'w') as f:
      	f.write('0')
      with open('tmp_counter', 'w') as f:
      	f.write('0')
      with open('tmp_signal', 'w') as f:
      	f.write('0')
      with open('tmp_start', 'w') as f:
      	f.write('0')
      with open('signal_1', 'w') as f:
      	f.write('')
      with open('signal_2', 'w') as f:
      	f.write('')


      os.system('nmcli dev wifi connect ESPap')  #Start jamming by connecting to wifi network
    comment: |-
      Resets all tmp files back to 0
      Connects to signal jammer wifi
    priority: ''
    section: main_after_init
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      import os
      os.system('nmcli con down id "ESPap 1"')
    comment: Disconnects from wifi
    priority: ''
    section: main_after_stop
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [band_pass_filter_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '0', blocks_peak_detector_xb_1, '0']
- [blocks_delay_0, '0', band_pass_filter_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', epy_block_3, '0']
- [blocks_peak_detector_xb_1, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_throttle_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_3, '0', blocks_null_sink_1, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', blocks_delay_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0_1, '0']

metadata:
  file_format: 1
